# Keil uVision project DC_Measure_V1.0.uvprojx, settings and files
target DC_Measure (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NANO100SD3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DC_Measure_V1.0 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\Library\CMSIS\Include;..\bsp\bus\inc;..\bsp\devices\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../Library/StdDriver/src/: adc.c clk.c crc.c dac.c ebi.c fmc.c gpio.c i2c.c i2s.c lcd.c pdma.c pwm.c retarget.c rtc.c sc.c scuart.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group User
    ../User/src/: YDT_1363-3.c
    ../User/: main.c
  group Bsp
    ../bsp/bus/src/: bus_485.c bus_i2c.c bus_spi.c
    ../bsp/devices/src/: 25L3233F.c HT7038.c LED.c MB85RS16NPN.c XL7026EI.c
