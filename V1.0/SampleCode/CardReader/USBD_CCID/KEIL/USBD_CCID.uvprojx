# Keil uVision project USBD_CCID.uvprojx, settings and files
target USBD_CCID (ARM-ADS)
  device: NANO110RE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: USBD_CCID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group User
    ../: descriptors.c main.c ccid.c Ccid_if.c sc_intf.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c clk.c sys.c sc.c
    ../../../../Library/SmartcardLib/: SmartCardLib_Keil.lib
software components: CMSIS:CORE 5.4.0
