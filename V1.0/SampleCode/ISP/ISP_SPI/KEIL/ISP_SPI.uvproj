# Keil uVision project ISP_SPI.uvproj, settings and files
target ISP_SPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO130KE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1EBFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NANO100_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_NANO100
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1ec00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c spi.c sys.c timer.c
